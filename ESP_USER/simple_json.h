/**
 * @file simple_json.h
 * @brief JSON string encoding and decoding for persisted Wi-Fi settings.
 */
#ifndef SIMPLE_JSON_H
#define SIMPLE_JSON_H
/* ==================== JSON encoding ==================== */
/**
 * @brief Encode a null-terminated UTF-8 string, including surrounding JSON quotes.
 * @param char__ptr_value Input text.
 * @return String Encoded JSON string.
 */
static String func__Simple_JsonQuote(const char *char__ptr_value)
{
    String string__out = "\"";
    const unsigned char *uint8_t__ptr_ch = (const unsigned char *)char__ptr_value;
    while (*uint8_t__ptr_ch != 0u)
    {
        unsigned char uint8_t__ch = *uint8_t__ptr_ch++;
        if (uint8_t__ch < 0x20u)
        {
            char char__escape[7];
            (void)snprintf(char__escape, sizeof(char__escape), "\\u%04x", (unsigned int)uint8_t__ch);
            string__out += char__escape;
        }
        else
        {
            if (uint8_t__ch == '"' || uint8_t__ch == '\\') string__out += '\\';
            string__out += (char)uint8_t__ch;
        }
    }
    string__out += '"';
    return string__out;
}
/* ==================== JSON decoding ==================== */
/**
 * @brief Read an escaped string field from settings generated by JsonQuote.
 * @param string__raw JSON object, char__ptr_key Field name, string__out Decoded text.
 * @return bool False on malformed strings, NUL or unsupported surrogate escapes.
 */
static bool func__Simple_JsonReadString(const String &string__raw, const char *char__ptr_key, String &string__out)
{
    String string__key = func__Simple_JsonQuote(char__ptr_key);
    int int__pos = string__raw.indexOf(string__key);
    if (int__pos < 0) return false;
    int__pos += (int)string__key.length();
    while (string__raw[int__pos] == ' ' || string__raw[int__pos] == '\t') int__pos++;
    if (string__raw[int__pos++] != ':') return false;
    while (string__raw[int__pos] == ' ' || string__raw[int__pos] == '\t') int__pos++;
    if (string__raw[int__pos++] != '"') return false;
    string__out = "";
    while (int__pos < (int)string__raw.length())
    {
        unsigned char uint8_t__ch = (unsigned char)string__raw[int__pos++];
        if (uint8_t__ch == '"') return true;
        if (uint8_t__ch < 0x20u) return false;
        if (uint8_t__ch == '\\')
        {
            char char__escape = string__raw[int__pos++];
            if (char__escape == 'u')
            {
                uint16_t uint16_t__code = 0u;
                for (unsigned int uint__i = 0u; uint__i < 4u; uint__i++)
                {
                    char char__hex = string__raw[int__pos++];
                    unsigned int uint__digit;
                    if (char__hex >= '0' && char__hex <= '9') uint__digit = (unsigned int)(char__hex - '0');
                    else if (char__hex >= 'a' && char__hex <= 'f') uint__digit = (unsigned int)(char__hex - 'a' + 10);
                    else if (char__hex >= 'A' && char__hex <= 'F') uint__digit = (unsigned int)(char__hex - 'A' + 10);
                    else return false;
                    uint16_t__code = (uint16_t)((uint16_t__code << 4) | uint__digit);
                }
                if (uint16_t__code == 0u || (uint16_t__code >= 0xD800u && uint16_t__code <= 0xDFFFu)) return false;
                if (uint16_t__code >= 0x800u) string__out += (char)(0xE0u | (uint16_t__code >> 12));
                if (uint16_t__code >= 0x80u) string__out += (char)((uint16_t__code >= 0x800u ? 0x80u : 0xC0u) | ((uint16_t__code >> 6) & 0x3Fu));
                string__out += (char)((uint16_t__code >= 0x80u ? 0x80u : 0u) | (uint16_t__code & (uint16_t__code >= 0x80u ? 0x3Fu : 0x7Fu)));
                continue;
            }
            if (char__escape == 'n') uint8_t__ch = '\n';
            else if (char__escape == 'r') uint8_t__ch = '\r';
            else if (char__escape == 't') uint8_t__ch = '\t';
            else if (char__escape == 'b') uint8_t__ch = '\b';
            else if (char__escape == 'f') uint8_t__ch = '\f';
            else if (char__escape == '"' || char__escape == '\\' || char__escape == '/') uint8_t__ch = (unsigned char)char__escape;
            else return false;
        }
        string__out += (char)uint8_t__ch;
    }
    return false;
}
#endif
